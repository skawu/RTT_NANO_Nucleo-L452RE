# Keil uVision project RTT_NANO_Nucleo-L452RE.uvprojx, settings and files
target RTT_NANO_Nucleo-L452RE (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L452RETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20027FFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: RTT_NANO_Nucleo-L452RE +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L452xx
  c include: ../Inc;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  group Application/MDK-ARM
    ./: startup_stm32l452xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Application/User
    ../Src/: main.c stm32l4xx_it.c stm32l4xx_hal_msp.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_cortex.c stm32l4xx_hal_tim.c stm32l4xx_hal_uart.c stm32l4xx_hal_flash.c stm32l4xx_hal_rcc.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_rcc_ex.c
software components: CMSIS:CORE 4.3.0
